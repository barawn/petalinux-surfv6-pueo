SRC_URI += "file://user_2024-10-04-14-44-00.cfg \
            file://user_2024-10-11-17-53-00.cfg \
            file://user_2024-10-12-16-13-00.cfg \
            file://user_2024-10-15-18-58-00.cfg \
            file://user_2024-10-24-14-18-00.cfg \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

