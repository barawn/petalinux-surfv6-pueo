XSTCH_BUILD_DEBUG = "1"
YAML_COMPILER_FLAGS:append = " -DFSBL_DEBUG_INFO"
