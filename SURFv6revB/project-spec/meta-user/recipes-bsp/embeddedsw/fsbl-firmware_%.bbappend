SRC_URI:append = " \
	       file://0001-add-FSBL-PHY-reset-hook.patch \
               "

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
